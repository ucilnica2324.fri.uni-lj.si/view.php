TYPE ST_recept :
STRUCT
	modra : INT := 50;
	rdeca : INT := 20;
	zelena: INT := 0;
	voda: INT := 10;
END_STRUCT
END_TYPE
