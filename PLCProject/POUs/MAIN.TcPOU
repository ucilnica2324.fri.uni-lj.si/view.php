PROGRAM MAIN
VAR
END_VAR

// NETWORK 1

END_PROGRAM
