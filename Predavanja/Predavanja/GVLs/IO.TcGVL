{attribute 'qualified_only'}
VAR_GLOBAL
	tipkaRdeca AT %I*: BOOL;
	luckaRdeca AT %Q*: BOOL;
END_VAR
