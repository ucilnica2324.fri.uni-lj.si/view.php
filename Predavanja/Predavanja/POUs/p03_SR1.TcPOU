PROGRAM p03_SR1
VAR
	// Set
	S0: BOOL;
	// Reset
	S1: BOOL;
	// Q
	L0: BOOL;
END_VAR

// NETWORK 1
L0 := (S0 OR L0) AND NOT S1;

// NETWORK 2

END_PROGRAM
